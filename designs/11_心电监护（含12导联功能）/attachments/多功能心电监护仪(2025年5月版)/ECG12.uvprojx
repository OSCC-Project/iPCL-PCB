# Keil uVision project ECG12.uvprojx, settings and files
target Program (6220000::V6.22::ARMCLANG)
  device: GD32F470ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x0B0000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECG12 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: .\Firmware\GD32F4xx_standard_peripheral\Include;.\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F4xx\Include;.\User;.\Hardware;.;.\Hardware\Pressure;.\Hardware\ControlBoard;.\Hardware\Screen;.\Hardware\Printer;.\Hardware\SpO2;.\Hardware\Monitor;.\Hardware\NAND_FatFS;.\Hardware\NAND_FatFS\inc;.\Hardware\NAND_FatFS\src;.\App\program;.\App\solution\ecg-solve;.\Hardware\rtc;.\App\solution\resp-solve;.\App\solution\nibp-solve;.\Hardware\COM
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xb0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: gd32f4xx_it.c main.c systick.c SEGGER_RTT.c SEGGER_RTT_printf.c DataType.h Timer.c SEGGER_RTT_Conf.h
  group App
    ./App/program/: monitor.c 12leadapp.c AppManager.c
    ./User/: font.h
    ./App/solution/ecg-solve/: ecgjudge.c
    ./App/solution/resp-solve/: respjudge.c
    ./App/solution/nibp-solve/: nibpsolve.c
  group Hardware
    ./: 12lead.c
    ./Hardware/Pressure/: pressure.c
    ./Hardware/ControlBoard/: ctrlbd.c
    ./Hardware/Screen/: screen_basic.c
    ./Hardware/Printer/: printer.c
    ./Hardware/SpO2/: SPO2.c DAC.c ADC.c
    ./Hardware/Monitor/: ecg_monitor.c resp_monitor.c
    ./Hardware/Sound/: sound.c
    ./Hardware/rtc/: bsp_rtc.c
    ./Hardware/COM/: uart.c
  group Firmware
    ./Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_dac.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_usart.c gd32f4xx_ipa.c gd32f4xx_pmu.c
  group FatFS
    ./Hardware/NAND_FatFS/: sdcard.c
    ./Hardware/NAND_FatFS/src/: diskio.c fattime.c ff.c ff_gen_drv.c ffsystem.c ffunicode.c
  group SMSIS
    ./Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Doc
    ./Doc/: readme.txt
